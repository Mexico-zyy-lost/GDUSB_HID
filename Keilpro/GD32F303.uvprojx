# Keil uVision project GD32F303.uvprojx, settings and files
target GD32F303 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\Code\Mains;..\Code\GD32Api\CMSIS;..\Code\GD32Api\F30x_stdperiph\Include;..\Code\Drivers;..\Code\Inc;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Firmware\GD32F30x_usbd_library\device\Include;..\..\Firmware\GD32F30x_usbd_library\usbd\Include;..\..\Firmware\GD32F30x_usbd_library\class\device\hid\Include;..\..\Utilities;..\..\Firmware\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Mains
    ../Code/Mains/: main.c systick.c gd32f30x_it.c gd32f30x_usbd_hw.c hid_keyboard_itf.c
    ../Code/GD32Api/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Drivers
    ../Code/Drivers/: led.c key.c usart.c myiic.c
  group GD32Api
    ../Code/GD32Api/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ../Code/GD32Api/F30x_stdperiph/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group USBD_Drivers
    ../Code/USBD_Drivers/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../Code/USBD_Device/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../Code/USBD_Class/: standard_hid_core.c
